# Keil uVision project interfacing_of_keyboard_&_lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RD2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: interfacing_of_keyboard_&_lcd
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: interfacing_of_keyboard_&_lcd.c interfacing_of_keyboard_&_lcd_2.c
